# Keil uVision project Project3.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: ece_spi.c MPU9250.c Retarget.c sensor_fusion.c uart.c Multi_thread.c led.c timer.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 1.0.0
